# Keil uVision project RYDWJZv2.uvprojx, settings and files
target RYDWJZ (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L471VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: RYDWJZ +hex
  AfterMake: fromelf --bin --output "$Lbin\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L471xx
  c include: ..\project;..\Libraries;..\Libraries\STM32L4xx_HAL_Driver\Inc;..\Libraries\CMSIS\Device\STM32L4xx\Include;..\Libraries\Core\Include;..\Libraries\CMSIS;..\Libraries\CMSIS\DSP\Include;..\Core;..\BSP;..\Driver\LSM6DSL;..\Driver\WT588F02B;..\Driver\W25Qxx;..\Driver\SSD1306;..\APP;..\APP\Lora;..\APP\RYDW;..\APP\RTK;..\APP\DTU;..\APP\Terminal;..\APP\Update;..\APP\IMU;..\APP\BLE;..\General;..\Driver\SX126x;..\APP\STORE;..\APP\OLED;..\APP\C;..\APP\Tool;..\APP\Charg;..\APP\uwb;..\APP\decadriver;..\APP\dw_app;..\APP\madgwick_app;..\APP\platform;..\APP\transGPS_app
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group CMSIS
    ../Core/: startup_stm32l471xx.s stm32l4xx_it.c system_stm32l4xx.c
  group hal
    ../Libraries/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c
    ../Libraries/: stm32l4xx_hal_conf.h
  group BSP
    ../BSP/: BSP.c BSP_debug.c BSP_DMA.c BSP_gpio.c BSP_i2c.c BSP_qspi.c BSP_ringbuf.c BSP_softi2c.c BSP_timer.c BSP_spi.c BSP_uart.c BSP_watchdog.c BSP_led.c BSP_adc.c BSP_button.c BSP.Store.c BSP_Voice.c BSP_EEProm.c bsp_dw1000.c bsp_dw1000_diag.c bsp_dw1000_official.c
    ../Core/: main.c
  group Driver/W25Qxx
    ../Driver/W25Qxx/: Drv_W25Qxx_QSPI.c w25qxxConf.h
  group Driver/LSM6DSL
    ../Driver/LSM6DSL/: lsm6dsl_reg.c
  group Driver/SSD1306
    ../Driver/SSD1306/: ssd1306.c ssd1306_fonts.c ssd1306_tests.c ssd1306_conf.h
  group APP/RYDW
    ../app/RYDW/: RYDW_StationCard.c
    ../APP/RYDW/: RYDW_Display.c RYDW_Def.h RYDW_CardInfo.c RYDW_Locate.c RYDW_Init.c RYDW_Postion.c
  group APP/RTK
    ../app/RTK/: GPS_Comm.c RTK_Comm.c
    ../APP/RTK/: CORS_Comm.c
  group APP/DTU
    ../app/DTU/: DTU_BulkData.c DTU_Comm.c DTU_Update.c
    ../APP/DTU/: DTU_Process.c app_dtu.c
  group APP/IMU
    ../APP/IMU/: IMU_Acc.c
  group APP/BLE
    ../APP/BLE/: BLE_Comm.c BLE_BaseStation.c
  group APP/Update
    ../APP/Update/: Update.c Dump.c iap.c IAP_bsdiff.c vFile.c
  group APP/Terminal
    ../APP/Terminal/: Cmd_DTU.c Cmd_Internal.c TerminalConf.h Cmd_SpiFlash.c Cmd_RYDW.c
  group GenFunc
    ../General/: g_func.c g_GlobalValDef.c gfunc_String.c
  group STORE
    ../APP/STORE/: APP_STORE.c
  group APP/OLED
    ../APP/OLED/: OLED.c
  group APP/TOOL
    ../APP/Tool/: app_tool.c
  group APP/C
    ../APP/C/: Type.c
  group APP/Charg
    ../APP/Charg/: IP2365.c
  group APP/UWB
    ../APP/uwb/: uwb_anchor.c uwb_data_transfer.c uwb_ranging.c uwb_tdma.c app_cmd.c
  group APP/Decadriver
    ../APP/decadriver/: deca_device.c deca_params_init.c
  group APP/DW
    ../APP/dw_app/: dw_main.c instance_anchor.c uwb_diag.c instance_tag.c
  group APP/Madgwick
    ../APP/madgwick_app/: madgwick_uwb_fusion.c
  group APP/Platform
    ../APP/platform/: deca_mutex.c deca_range_tables.c deca_sleep.c deca_spi.c port.c
  group APP/transGPS
    ../APP/transGPS_app/: uwb_gps_transform.c
