#include <string.h>
#include <stdio.h>
#include "ssd1306.h"
#include "ssd1306_tests.h"
#include "ssd1306_fonts.h"
#include "RYDW_Display.h"
#include "GPS_Comm.h"
#include "RYDW_Locate.h"
#include "RYDW_Postion.h"
#include "app_tool.h"
#include "g_GlobalValDef.h"
#include "RYDW_Init.h"
//------------------------------------------------------------------------------
// Table generated by LCD Assistant
// http://en.radzio.dxp.pl/bitmap_converter/
//------------------------------------------------------------------------------

const unsigned char github_SHlogo_128x64[] = {
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x47,0xE2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xC7,0xE3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xC7,0xE3,0x80,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xC7,0xE3,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xC7,0xE3,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xC7,0xE3,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xC7,0xE3,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xC7,0xE3,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xC7,0xE3,0x80,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xC0,0x03,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xC0,0x03,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xC7,0xE3,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xC7,0xE3,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x0F,0xC7,0xE3,0xF0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xC7,0xE3,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xC7,0xE3,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xC7,0xE3,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xC7,0xE3,0x80,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xC7,0xE3,0x80,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xC7,0xE2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xE0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00
};

void ssd1306_TestBorder() {
    ssd1306_Fill(Black);
   
    uint8_t x = 0;
    uint8_t y = 0;
    do {
        ssd1306_DrawPixel(x, y, Black);

        if((y == 0) && (x < (SSD1306_WIDTH-1)))
            x++;
        else if((x == (SSD1306_WIDTH-1)) && (y < (SSD1306_HEIGHT-1)))
            y++;
        else if((y == (SSD1306_HEIGHT-1)) && (x > 0)) 
            x--;
        else
            y--;

        ssd1306_DrawPixel(x, y, White);
        ssd1306_UpdateScreen();
    
        HAL_Delay(5);
    } while(x > 0 || y > 0);
   
    HAL_Delay(1000);
}

void ssd1306_TestFonts1() {
    uint8_t y = 0;
    ssd1306_Fill(Black);

    #ifdef SSD1306_INCLUDE_FONT_16x26
    ssd1306_SetCursor(2, y);
//    ssd1306_WriteString("Font 16x26", Font_16x26, White);
    y += 26;
    #endif

    #ifdef SSD1306_INCLUDE_FONT_11x18
    ssd1306_SetCursor(2, y);
    ssd1306_WriteString("Font 11x18", Font_11x18, White);
    y += 18;
    #endif

    #ifdef SSD1306_INCLUDE_FONT_7x10
    ssd1306_SetCursor(2, y);
//    ssd1306_WriteString("Font 7x10", Font_7x10, White);
    y += 10;
    #endif

    #ifdef SSD1306_INCLUDE_FONT_6x8
    ssd1306_SetCursor(2, y);
    ssd1306_WriteString("Font 6x8", Font_6x8, White);
    #endif

    ssd1306_UpdateScreen();
}

/*
 * This test shows how an 128x64 px OLED can replace a 0802 LCD.
 */
void ssd1306_TestFonts2() {
#ifdef SSD1306_INCLUDE_FONT_16x24
    uint8_t x1, y1, x2, y2;

    ssd1306_Fill(Black);

    ssd1306_SetCursor(0, 4);
    ssd1306_WriteString("18.092.5", Font_16x24, White);
    ssd1306_SetCursor(0, 4+24+8);
    ssd1306_WriteString("RIT+1000", Font_16x24, White);

    // underline
    x1 = 6*16;
    y1 = 4+24+8+24;
    x2 = x1+16;
    y2 = y1+2;
    ssd1306_FillRectangle(x1, y1, x2, y2, White);

    ssd1306_UpdateScreen();
#endif
}

/*
 * Test of proportional (non-monospaced) font.
 */
void ssd1306_TestFonts3() {
    ssd1306_Fill(Black);
#ifdef SSD1306_INCLUDE_FONT_16x15
    ssd1306_SetCursor(4, 4);
    ssd1306_WriteString("Proportional", Font_16x15, White);
    ssd1306_SetCursor(4, 24);
    ssd1306_WriteString("text... Sweet!", Font_16x15, White);
    ssd1306_SetCursor(4, 44);
    ssd1306_WriteString("3.1415  04:20", Font_16x15, White);
#elif defined(SSD1306_INCLUDE_FONT_11x18)
    ssd1306_SetCursor(4, 4);
    ssd1306_WriteString("Skip test", Font_11x18, White);
    ssd1306_SetCursor(4, 24);
    ssd1306_WriteString("Font not", Font_11x18, White);
    ssd1306_SetCursor(4, 44);
    ssd1306_WriteString("included!", Font_11x18, White);
#endif
    ssd1306_UpdateScreen();
}

void ssd1306_TestFPS() {
    ssd1306_Fill(White);
   
    uint32_t start = HAL_GetTick();
    uint32_t end = start;
    int fps = 0;
    char message[] = "ABCDEFGHIJK";
   
    ssd1306_SetCursor(2,0);
    ssd1306_WriteString("Testing...", Font_11x18, Black);
    ssd1306_SetCursor(2, 18*2);
    ssd1306_WriteString("0123456789A", Font_11x18, Black);
   
    do {
        ssd1306_SetCursor(2, 18);
        ssd1306_WriteString(message, Font_11x18, Black);
        ssd1306_UpdateScreen();
       
        char ch = message[0];
        memmove(message, message+1, sizeof(message)-2);
        message[sizeof(message)-2] = ch;

        fps++;
        end = HAL_GetTick();
    } while((end - start) < 5000);
   
    HAL_Delay(5000);

    char buff[64];
    fps = (float)fps / ((end - start) / 1000.0);
    snprintf(buff, sizeof(buff), "~%d FPS", fps);
   
    ssd1306_Fill(White);
    ssd1306_SetCursor(2, 2);
    ssd1306_WriteString(buff, Font_11x18, Black);
    ssd1306_UpdateScreen();
}

void ssd1306_TestLine() {

  ssd1306_Line(1,1,SSD1306_WIDTH - 1,SSD1306_HEIGHT - 1,White);
  ssd1306_Line(SSD1306_WIDTH - 1,1,1,SSD1306_HEIGHT - 1,White);
  ssd1306_UpdateScreen();
  return;
}

void ssd1306_TestRectangle() {
  uint32_t delta;

  for(delta = 0; delta < 5; delta ++) {
    ssd1306_DrawRectangle(1 + (5*delta),1 + (5*delta) ,SSD1306_WIDTH-1 - (5*delta),SSD1306_HEIGHT-1 - (5*delta),White);
  }
  ssd1306_UpdateScreen();
  return;
}

void ssd1306_TestRectangleFill() {
  ssd1306_FillRectangle(31, 1, 65, 35, White);
  ssd1306_FillRectangle(10, 45, 70, 60, White);
  ssd1306_FillRectangle(75, 10, 100, 45, White);
  ssd1306_FillRectangle(55, 30, 80, 55, Black);
  ssd1306_UpdateScreen();
}

void ssd1306_TestRectangleInvert() {
#ifdef SSD1306_INCLUDE_FONT_11x18
  ssd1306_SetCursor(2, 0);
  ssd1306_WriteString("Black", Font_11x18, White);
  ssd1306_SetCursor(2, 20);
  ssd1306_WriteString("on", Font_11x18, White);
  ssd1306_SetCursor(2, 40);
  ssd1306_WriteString("White", Font_11x18, White);
  ssd1306_SetCursor(66, 0);
  ssd1306_WriteString("White", Font_11x18, White);
  ssd1306_SetCursor(66, 20);
  ssd1306_WriteString("on", Font_11x18, White);
  ssd1306_SetCursor(66, 40);
  ssd1306_WriteString("Black", Font_11x18, White);
#else
  ssd1306_FillCircle(32, 32, 20, White);
  ssd1306_FillCircle(96, 32, 20, White);
#endif
  ssd1306_InvertRectangle(0,0,63,63);
  /* Test rectangle lies on one 8px page */
  ssd1306_InvertRectangle(2,58,125,60);
  ssd1306_UpdateScreen();
}

void ssd1306_TestCircle() {
  uint32_t delta;

  for(delta = 0; delta < 5; delta ++) {
    ssd1306_DrawCircle(20*delta+30, 15, 10, White);
  }

  for(delta = 0; delta < 5; delta ++) {
    ssd1306_FillCircle(23*delta+15, 40, 10, White);
  }

  ssd1306_UpdateScreen();
  return;
}

void ssd1306_TestArc() {
  ssd1306_DrawArc(30, 30, 30, 20, 270, White);
  ssd1306_DrawArcWithRadiusLine(80, 55, 10, 30, 270, White);
  ssd1306_UpdateScreen();
  return;
}

void ssd1306_TestPolyline() {
  SSD1306_VERTEX loc_vertex[] =
  {
      {35,40},
      {40,20},
      {45,28},
      {50,10},
      {45,16},
      {50,10},
      {53,16}
  };

  ssd1306_Polyline(loc_vertex,sizeof(loc_vertex)/sizeof(loc_vertex[0]),White);
  ssd1306_UpdateScreen();
  return;
}
void ssd1306_InitDrawBitmap()
{
    ssd1306_Fill(Black);
    ssd1306_DrawBitmap(0,0,github_SHlogo_128x64,128,64,White);
	ssd1306_UpdateScreen();	//刷新·
	HAL_Delay(1000);
	ssd1306_Fill(Black);
	ssd1306_DrawBitmap(30,3,she_12x12,12,12,White);       /*设*/
	ssd1306_DrawBitmap(42,3,bei_12x12,12,12,White);       /*备*/
	ssd1306_DrawBitmap(54,3,zi_12x12,12,12,White);        /*自*/
	ssd1306_DrawBitmap(66,3,jian_12x12,12,12,White);	  /*检*/
	ssd1306_DrawBitmap(78,3,zhong_12x12,12,12,White);	  /*中*/
	ssd1306_DrawBitmap(90,3,fuhao_12x6,6,12,White);	      /*.*/
	ssd1306_DrawBitmap(96,3,fuhao_12x6,6,12,White);	      /*.*/
	ssd1306_DrawBitmap(102,3,fuhao_12x6,6,12,White);	  /*.*/
	
//	ssd1306_DrawBitmap(6,27,L_12x6,6,12,White);	          /*L*/
//	ssd1306_DrawBitmap(12,27,o_12x6,6,12,White);	      /*o*/
//	ssd1306_DrawBitmap(18,27,R_12x6,6,12,White);	      /*R*/
//	ssd1306_DrawBitmap(24,27,A_12x6,6,12,White);	      /*A*/
	ssd1306_DrawBitmap(6,27,I_12x6,6,12,White);	          /*I*/
	ssd1306_DrawBitmap(12,27,M_12x6,6,12,White);	      /*M*/
	ssd1306_DrawBitmap(18,27,U_12x6,6,12,White);	      /*U*/	

	ssd1306_DrawBitmap(72,27,lan_12x12,12,12,White);	  /*蓝*/
	ssd1306_DrawBitmap(84,27,ya_12x12,12,12,White);	      /*牙*/

	ssd1306_DrawBitmap(6,48,R_12x6,6,12,White);	      	  /*R*/
	ssd1306_DrawBitmap(12,48,T_12x6,6,12,White);	      /*T*/
	ssd1306_DrawBitmap(18,48,K_12x6,6,12,White);	      /*K*/

    ssd1306_DrawBitmap(72,48,D_12x6,6,12,White);	      /*D*/
	ssd1306_DrawBitmap(78,48,T_12x6,6,12,White);	      /*T*/
	ssd1306_DrawBitmap(84,48,U_12x6,6,12,White);	      /*U*/
	
	ssd1306_UpdateScreen();	                              //刷新
}

/*****主界面函数*******/
void ssd1306_maininterface(void)
{
	if(g_OpenOLEDPower == 1)
	{
		ssd1306_Fill(Black);

		RYDW_DispBattery(g_fBatVal);		   /*电池*/				
		RYDW_DispGPS(g_GPSInfo.uMode);		   /*定位模块*/    
		SendNetSignal();                       /*信号显示*/	
		RYDW_DispSignal(g_Signal);
		RYDW_DispTime(g_SysTime, 47, 5);	   /*时间*/	
	//    ssd1306_DrawBitmap(14,27,zai_12x12,12,12,White);	      /*在*/
	//	ssd1306_DrawBitmap(26,27,xian_12x12,12,12,White);	      /*线*/
	//	ssd1306_DrawBitmap(38,27,ren_12x12,12,12,White);	      /*人*/
	//	ssd1306_DrawBitmap(50,27,shu_12x12,12,12,White);	      /*数*/
		
		ssd1306_DrawBitmap(14,27,she_12x12,12,12,White);	      /*设*/
		ssd1306_DrawBitmap(26,27,bei_12x12,12,12,White);	      /*备*/
		ssd1306_DrawBitmap(38,27,zhuang_12x12,12,12,White);	      /*状*/
		ssd1306_DrawBitmap(50,27,tai_12x12,12,12,White);	      /*态*/	

		ssd1306_DrawBitmap(14,48,gon_12x12,12,12,White);	      /*工*/
		ssd1306_DrawBitmap(26,48,zuo_12x12,12,12,White);	      /*作*/
		ssd1306_DrawBitmap(38,48,mo_12x12,12,12,White);	          /*模*/
		ssd1306_DrawBitmap(50,48,shi_12x12,12,12,White);	      /*式*/

		SeleWorkMode(g_SeleWorkMode,0x00);  /*正常高亮*/
	//	ssd1306_DrawBitmap(68,48,zheng_12x12,12,12,White);	      /*正*/
	//	ssd1306_DrawBitmap(80,48,chang_12x12,12,12,White);	      /*常*/
		
		ssd1306_DrawBitmap(2,30,Arrow_Lev,8,7,White);	          /*→*/
	//    ssd1306_DrawBitmap(14,48,bao_12x12,12,12,White);	      /*报*/
	//	ssd1306_DrawBitmap(26,48,jing_12x12,12,12,White);	      /*警*/
	//	ssd1306_DrawBitmap(38,48,ren_12x12,12,12,White);	      /*人*/
	//	ssd1306_DrawBitmap(50,48,shu_12x12,12,12,White);	      /*数*/
		
	//    ssd1306_DrawBitmap(80,48,Four_12x6,6,12,White);	       /*4*/
	//	ssd1306_DrawBitmap(86,48,G_12x6,6,12,White);	           /*G*/
	//	ssd1306_DrawBitmap(92,48,mo_12x12,12,12,White);	           /*模*/
	//	ssd1306_DrawBitmap(104,48,kuai_12x12,12,12,White);	       /*块*/	
		ssd1306_UpdateScreen();	  	//刷新
		if(g_MarkWarnFlag == 1)
			ssd1306_CORSBenchmarkface();
	}
}

/*****基站CORS/基准未设函数*******/
void ssd1306_CORSBenchmarkface(void)
{
	ssd1306_FillRectangle(74, 27, 74 + 36, 27 + 12, Black);
	ssd1306_UpdateScreen();
    if(g_ModeInFlash.type == 0)
	{
		ssd1306_DrawBitmap(74,27,ji_12x12,12,12,White);	          /*基*/
		ssd1306_DrawBitmap(86,27,zhun_12x12,12,12,White);	      /*准*/	
	}
	else if(g_ModeInFlash.type == 1)
	{
		ssd1306_DrawBitmap(74,27,C_12x6,6,12,White);	      /*C*/
		ssd1306_DrawBitmap(80,27,O_12x6,6,12,White);	      /*O*/
		ssd1306_DrawBitmap(86,27,R_12x6,6,12,White);	      /*R*/
		ssd1306_DrawBitmap(92,27,S_12x6,6,12,White);	      /*S*/		
	}
	ssd1306_DrawBitmap(98,27,cha_12x12,12,12,White);	      /*×*/	
	ssd1306_UpdateScreen();	                                  //刷新	
}


void LedPowerONShow(void)
{
	ssd1306_Fill(Black);
	if(g_DispPage ==1 || g_DispPage == 2)
	{
		RYDW_DispBattery(g_fBatVal);		   /*电池*/				
		RYDW_DispGPS(g_GPSInfo.uMode);		   /*定位模块*/    
		RYDW_DispSignal(g_Signal);
		SendNetSignal();                       /*信号显示*/	
		RYDW_DispTime(g_SysTime, 47, 5);	   /*时间*/	
		
		ssd1306_DrawBitmap(14,27,she_12x12,12,12,White);	      /*设*/
		ssd1306_DrawBitmap(26,27,bei_12x12,12,12,White);	      /*备*/
		ssd1306_DrawBitmap(38,27,zhuang_12x12,12,12,White);	      /*状*/
		ssd1306_DrawBitmap(50,27,tai_12x12,12,12,White);	      /*态*/	

		ssd1306_DrawBitmap(14,48,gon_12x12,12,12,White);	      /*工*/
		ssd1306_DrawBitmap(26,48,zuo_12x12,12,12,White);	      /*作*/
		ssd1306_DrawBitmap(38,48,mo_12x12,12,12,White);	          /*模*/
		ssd1306_DrawBitmap(50,48,shi_12x12,12,12,White);	      /*式*/

		if(g_DispPage == 2)  //高亮
		{
			SeleWorkMode(g_SeleWorkMode,0x01);  /*正常高亮*/	
			ssd1306_DrawBitmap(2,51,Arrow_Lev,8,7,White);	          /*→*//*移动光标*/	
		}
		else if(g_DispPage == 1)
		{
			SeleWorkMode(g_SeleWorkMode,0x00);  /*正常高亮*/ 
			 if(g_SeleWorkMode == 1)   //是否打点
			 {
				ShowLinItrm(g_BribeFlag.RouLin);/*界面显示*/
				ShowBribeRun(g_BribeFlag.run);/*界面显示*/ 
			 }
			 if(g_CursorPos == 0)  //箭头位置
			 {
				ssd1306_DrawBitmap(2,30,Arrow_Lev,8,7,White);	          /*→*//*移动光标*/
			 }
			 else
			 {
				ssd1306_DrawBitmap(2,51,Arrow_Lev,8,7,White);	          /*→*//*移动光标*/
			 } 
		}
	}
	ssd1306_UpdateScreen();	                              //刷新
	if(g_MarkWarnFlag == 1)
		ssd1306_CORSBenchmarkface();	
}



void ssd1306_ZhengChang(uint8_t x, uint8_t y, SSD1306_COLOR color,uint8_t flag)
{
//	if(flag == 0x01) //正常	
//		ssd1306_DrawBitmap(x,y,zheng_12x12,12,12,color);	  /*正*/
//	else if(flag == 0x00)  //异常
//		ssd1306_DrawBitmap(x,y,yi_12x12,12,12,color);	      /*异*/
//	ssd1306_DrawBitmap(x+12,y,chang_12x12,12,12,color);	      /*常*/
	
	if(flag == 0x01) //正常	
		ssd1306_DrawBitmap(x,y,duigou_12x12,12,12,color);	  /*正*/
	else if(flag == 0x00)  //异常
		ssd1306_DrawBitmap(x,y,cha_12x12,12,12,color);	      /*异*/		
	ssd1306_UpdateScreen();	                              //刷新
}
void ssd1306_TestDrawBitmap()
{
//    ssd1306_Fill(White);
//    ssd1306_DrawBitmap(0,0,garfield_128x64,128,64,Black);
//    ssd1306_UpdateScreen();
//    HAL_Delay(3000);
//    ssd1306_Fill(Black);
//    ssd1306_DrawBitmap(32,0,github_logo_64x64,64,64,White);
//    ssd1306_UpdateScreen();
//    HAL_Delay(3000);
//    ssd1306_Fill(White);
//    ssd1306_DrawBitmap(32,0,github_logo_64x64,64,64,Black);
//    ssd1306_UpdateScreen();
}

void ssd1306_TestAll() {
    ssd1306_Init();

    ssd1306_TestFPS();
    HAL_Delay(3000);
    ssd1306_TestBorder();
    ssd1306_TestFonts1();
    HAL_Delay(3000);
    ssd1306_TestFonts2();
    HAL_Delay(3000);
    ssd1306_TestFonts3();
    HAL_Delay(3000);
    ssd1306_Fill(Black);
    ssd1306_TestRectangle();
    ssd1306_TestLine();
    HAL_Delay(3000);
    ssd1306_Fill(Black);
    ssd1306_TestRectangleFill();
    HAL_Delay(3000);
    ssd1306_Fill(Black);
    ssd1306_TestRectangleInvert();
    HAL_Delay(3000);
    ssd1306_Fill(Black);
    ssd1306_TestPolyline();
    HAL_Delay(3000);
    ssd1306_Fill(Black);
    ssd1306_TestArc();
    HAL_Delay(3000);
    ssd1306_Fill(Black);
    ssd1306_TestCircle();
    HAL_Delay(3000);
    ssd1306_TestDrawBitmap();
    HAL_Delay(3000);
}

